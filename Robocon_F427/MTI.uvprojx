# Keil uVision project MTI.uvprojx, settings and files
target Robocon_KIZUNA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MTI +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,__FPU_USED=1
  c misc: --c99
  c include: ..\MTI_USER;..\CORE;..\FWLB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Robocon_F427;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MTI_USER;..\THE_DOG
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MAIN
    ./: main.c main.h system_stm32f4xx.c
  group MTI_USER
    ../MTI_USER/: gpio.c gpio.h nvic.c nvic.h can.c can.h timer.c timer.h uart.c uart.h dma.c dma.h stm32f4xx_it.c stm32f4xx_it.h remote.c remote.h hi219m.c hi219m.h imu_data_decode.c imu_data_decode.h packet.c packet.h pid.c pid.h M3508.c M3508.h user_task.c user_task.h
  group THE_DOG
    ../THE_DOG/: BASE_POINT.c BASE_POINT.h cal_status.c cal_status.h Make_keep_high.c Make_keep_high.h Make_The_Blance.c Make_The_Blance.h PID_states.c PID_states.h remoto_control.c remoto_control.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group FWLIB
    ../FWLB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CORE
    ../CORE/: startup_stm32f427xx.s core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
